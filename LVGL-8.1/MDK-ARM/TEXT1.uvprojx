# Keil uVision project TEXT1.uvprojx, settings and files
target TEXT1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: TEXT1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --diag_suppress=68 --diag_suppress=188 --diag_suppress=1 --diag_suppress=546 --diag_suppress=111
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../MyApplication;../SYSTEM;../TOUCH;../LVGL_GUI/src;../LVGL_GUI;../LVGL_Port;../../TEXT1(2);../LVGL_GUI/examples/porting;../LVGL_GUI/lvgl;../LVGL_AAPP/test;..\LVGL_AAPP\text2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fsmc.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fsmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group MyApplication
    ../MyApplication/: MyInit.c Public.c System.c CallBack.c LED.c Timer6.c
    ../TOUCH/: 24cxx.c ctiic.c ft5206.c gt9147.c lcd.c myiic.c ott2001a.c touch.c
  group SYSTEM
    ../SYSTEM/: sys.c delay.c
  group GUI_LVGL
    ../LVGL_GUI/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL_GUI/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL_GUI/src/extra/layouts/flex/: lv_flex.c
    ../LVGL_GUI/src/extra/layouts/grid/: lv_grid.c
    ../LVGL_GUI/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL_GUI/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL_GUI/src/extra/themes/default/: lv_theme_default.c
    ../LVGL_GUI/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL_GUI/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL_GUI/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL_GUI/src/extra/widgets/chart/: lv_chart.c
    ../LVGL_GUI/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL_GUI/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL_GUI/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL_GUI/src/extra/widgets/led/: lv_led.c
    ../LVGL_GUI/src/extra/widgets/list/: lv_list.c
    ../LVGL_GUI/src/extra/widgets/meter/: lv_meter.c
    ../LVGL_GUI/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL_GUI/src/extra/widgets/span/: lv_span.c
    ../LVGL_GUI/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL_GUI/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL_GUI/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL_GUI/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL_GUI/src/extra/widgets/win/: lv_win.c
    ../LVGL_GUI/src/extra/: lv_extra.c
    ../LVGL_GUI/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../LVGL_GUI/src/gpu/sdl/: lv_gpu_sdl_draw_arc.c lv_gpu_sdl_draw_blend.c lv_gpu_sdl_draw_img.c lv_gpu_sdl_draw_label.c lv_gpu_sdl_draw_line.c lv_gpu_sdl_draw_rect.c lv_gpu_sdl_lru.c lv_gpu_sdl_mask.c lv_gpu_sdl_stack_blur.c lv_gpu_sdl_texture_cache.c lv_gpu_sdl_utils.c
    ../LVGL_GUI/src/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_sdl.c lv_gpu_stm32_dma2d.c
    ../LVGL_GUI/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL_GUI/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL_GUI/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_Portt
    ../LVGL_GUI/examples/porting/: lv_port_disp.c lv_port_indev_template.c
    ../: lv_conf.h
  group GUI_APP
    ../LVGL_AAPP/test/: test.c test.h
  group 408-GUI
    ../LVGL_AAPP/text2/: 408.c C.c LOGO.c OscStyle.c
software components: CMSIS:CORE 4.3.0
